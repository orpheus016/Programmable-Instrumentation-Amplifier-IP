v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {tests/tran_logic_not.sym} 10 -20 0 0 {name=x1}
